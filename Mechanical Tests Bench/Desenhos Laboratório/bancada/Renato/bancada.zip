# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (file degrau.prt.1)

Parameters:
  DESCRIPTION = "degrau"
  PTC_COMMON_NAME = "degrau.prt"