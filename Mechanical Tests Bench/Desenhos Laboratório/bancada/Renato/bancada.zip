# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (file base.prt.1)

Parameters:
  DESCRIPTION = "basa"
  PTC_COMMON_NAME = "base.prt"