# Pro/ENGINEER assembly, saved by Pro/ENGINEER Wildfire 2.0 (file desenhomont.asm.1)

Parameters:
  PTC_COMMON_NAME = "desenhomont.asm"