# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (file degrau.prt.2)

Parameters:
  DESCRIPTION = "degrau"
  PTC_COMMON_NAME = "degrau.prt"